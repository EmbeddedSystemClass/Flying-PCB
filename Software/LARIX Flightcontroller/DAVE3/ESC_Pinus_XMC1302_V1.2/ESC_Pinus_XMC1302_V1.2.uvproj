# Keil uVision project ESC_Pinus_XMC1302_V1.2.uvproj, settings and files
target XMC1302-200 (ARM-ADS)
  device: XMC1302-200 Infineon
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0x10001000-0x10032FFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: ESC_Pinus_XMC1302_V1.2
  c flags: Optim=1
  c misc: --c99
  c include: C:/DAVE-3.1.10/CMSIS/Include;C:/DAVE-3.1.10/CMSIS/Infineon/Include;C:/DAVE-3.1.10/emWin/Start/GUI/inc;C:/DAVE-3.1.10/CMSIS/Infineon/XMC1300_series/Include;Dave/Generated/inc/MATHLIBS;Dave/Generated/inc/DAVESupport;Dave/Generated/inc/MOTORLIBS;Dave/Generated/inc/LIBS
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x10001000 size 0x32000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group Dave_Generated_src_ADCGLOB001
    ./Dave/Generated/src/ADCGLOB001/: ADCGlob001.c ADCGlob001_Conf.c
  group Dave_Generated_src_CCU4GLOBAL
    ./Dave/Generated/src/CCU4GLOBAL/: CCU4GLOBAL.c CCU4GLOBAL_Conf.c
  group Dave_Generated_src_CCU8GLOBAL
    ./Dave/Generated/src/CCU8GLOBAL/: CCU8GLOBAL.c CCU8GLOBAL_Conf.c
  group Dave_Generated_src_CLK002
    ./Dave/Generated/src/CLK002/: CLK002.c
  group Dave_Generated_src_DAVESupport
    ./Dave/Generated/src/DAVESupport/: DAVE3.c MULTIPLEXER.c
  group Dave_Generated_src_IO004
    ./Dave/Generated/src/IO004/: IO004.c IO004_Conf.c
  group Dave_Generated_src_LIBS
    ./Dave/Generated/src/LIBS/: CCU8PWMLIB.c MOTORLIB.c
  group Dave_Generated_src_MATHLIBS
    ./Dave/Generated/src/MATHLIBS/: FASTMATH01.c MATH01.c MATHLLD01.c STDMATH01.c
  group Dave_Generated_src_NVIC002
    ./Dave/Generated/src/NVIC002/: NVIC002.c NVIC002_Conf.c
  group Dave_Generated_src_UART001
    ./Dave/Generated/src/UART001/: UART001.c UART001_Conf.c
  group ESC_Pinus_XMC1302_V1.2
    ./: ADC.c BlockCommutation.c DaisyChain.c Main.c
  group Lib
    ./Lib/: System_LibcStubs.c
  group Startup
    ./Startup/: startup_XMC1300_arm.s system_XMC1300.c
